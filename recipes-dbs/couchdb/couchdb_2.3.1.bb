require ${PN}.inc

SRC_URI[md5sum] = "ddf01b8a10a5b2901a87f1891d3bd7f4"
SRC_URI[sha256sum] = "43eb8cec41eb52871bf22d35f3e2c2ce5b806ebdbce3594cf6b0438f2534227d"
